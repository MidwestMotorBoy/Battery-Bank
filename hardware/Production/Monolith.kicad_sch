File: hardware/Production/Monolith.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Layout in progress
Connections:
- no-connect marks 2 -> 1
